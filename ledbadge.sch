File: ledbadge.sch (KiCad schematic (older format))
At the start: 399 parts, among them J1 Conn_01x06, J10 TEST_1P, J2 Conn_01x02, J3 Conn_01x02, J4 TEST_1P, J5 TEST_1P, J6 TEST_1P, J7 TEST_1P, J8 TEST_1P, J9 TEST_1P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

Commit message: Added test points for the RGB led data lines
Parts:
- added J? (x20): TEST_1P, symbol TEST_1P
Connections:
- net SCK100: now also J?.1
- net SCK120: now also J?.1
- net SCK140: now also J?.1
- net SCK160: now also J?.1
- net SCK180: now also J?.1
- net SCK20: now also J?.1
- net SCK200: now also J?.1
- net SCK40: now also J?.1
- net SCK60: now also J?.1
- net SCK80: now also J?.1
- net SDO100: now also J?.1
- net SDO120: now also J?.1
- net SDO140: now also J?.1
- net SDO160: now also J?.1
- net SDO180: now also J?.1
- net SDO20: now also J?.1
- net SDO200: now also J?.1
- net SDO40: now also J?.1
- net SDO60: now also J?.1
- net SDO80: now also J?.1
Other:
- moved on the sheet: C53, R28, R29, RV1

Commit message: Fixed a few ERC things and added USB power input option
Parts:
- added J22: USB_B, symbol USB_B
- added J28: GS3, Connectors:GS3, symbol GS3
- added X1: Badgelife_shitty_connector, symbol Badgelife_shitty_connector
- gave numbers to parts that had none: 113
- renumbered C18 to C35, C19 to C36, C20 to C37, C21 to C38, C22 to C39, C23 to C40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
Connections:
- net SCO120 is gone; now on net SDO120: D121.2 (SDI)
- net +3V3: now also X1.1 (VDD)
- net +5V: now also J28.1 (G1)
- net +BATT: no longer C64.1, C65.1, C66.1, U8.3 (VI)
- net GND: now also J22.4 (GND), J22.5 (Shield), X1.2 (GND)
- net SCL2: now reaches R56.1
- net SCL2: now also X1.4 (SDA)
- net SDA2: now reaches R58.2
- net SDA2: now also X1.3 (SCL)
- new net: C64.1, C65.1, C66.1, J28.2 (G2), U8.3 (VI)
- new net USB_VBUS: J22.1 (VBUS), J28.3 (G3)
Other:
- moved on the sheet: C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C68, C69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

Commit message: Fixed up some ERC things and generated netlist
Parts:
- added R105: R, symbol R
Connections:
- net +3V3: now also R105.2
- net SERIAL_PWR: now also R105.1
- no-connect marks 0 -> 65
Other:
- moved on the sheet: R4, R5
Changed lines of the file:
@@
 L R R4
 U 1 1 5B124224
-P 15300 8850
-F 0 "R4" V 15380 8850 50  0000 C CNN
-F 1 "R" V 15300 8850 50  0000 C CNN
-F 2 "" V 15230 8850 50  0001 C CNN
-F 3 "" H 15300 8850 50  0001 C CNN
-	1    15300 8850
-	0    1    1    0
+P 15750 8850
+F 0 "R4" V 15830 8850 50  0000 C CNN
+F 1 "R" V 15750 8850 50  0000 C CNN
+F 2 "" V 15680 8850 50  0001 C CNN
+F 3 "" H 15750 8850 50  0001 C CNN
+	1    15750 8850
+	0    1    -1   0
 $EndComp
 $Comp
 L R R5
 U 1 1 5B12456F
-P 15600 8950
-F 0 "R5" V 15680 8950 50  0000 C CNN
-F 1 "R" V 15600 8950 50  0000 C CNN
-F 2 "" V 15530 8950 50  0001 C CNN
-F 3 "" H 15600 8950 50  0001 C CNN
-	1    15600 8950
+P 16100 8950
+F 0 "R5" V 16180 8950 50  0000 C CNN
+F 1 "R" V 16100 8950 50  0000 C CNN
+F 2 "" V 16030 8950 50  0001 C CNN
+F 3 "" H 16100 8950 50  0001 C CNN
+	1    16100 8950
 	0    1    1    0
 $EndComp
@@
 $EndComp
 $Comp
-L PWR_FLAG #FLG058
-U 1 1 5B151808
-P 3150 950
-F 0 "#FLG058" H 3150 1025 50  0001 C CNN
-F 1 "PWR_FLAG" H 3150 1100 50  0000 C CNN
-F 2 "" H 3150 950 50  0001 C CNN
-F 3 "" H 3150 950 50  0001 C CNN
-	1    3150 950
-	1    0    0    -1
-$EndComp
-$Comp
-L PWR_FLAG #FLG059
-U 1 1 5B1534CC
-P 3150 1350
-F 0 "#FLG059" H 3150 1425 50  0001 C CNN
-F 1 "PWR_FLAG" H 3150 1500 50  0000 C CNN
-F 2 "" H 3150 1350 50  0001 C CNN
-F 3 "" H 3150 1350 50  0001 C CNN
-	1    3150 1350
-	1    0    0    -1
-$EndComp
-$Comp
 L POT RV1
 U 1 1 5B156FDF
@@
 $EndComp
 $Comp
-L GND #PWR060
+L GND #PWR058
 U 1 1 5B157AE9
 P 15050 14750
-F 0 "#PWR060" H 15050 14500 50  0001 C CNN
+F 0 "#PWR058" H 15050 14500 50  0001 C CNN
 F 1 "GND" H 15050 14600 50  0000 C CNN
 F 2 "" H 15050 14750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L +3V3 #PWR061
+L +3V3 #PWR059
 U 1 1 5B157E7E
 P 15050 14450
-F 0 "#PWR061" H 15050 14300 50  0001 C CNN
+F 0 "#PWR059" H 15050 14300 50  0001 C CNN
 F 1 "+3V3" H 15050 14590 50  0000 C CNN
 F 2 "" H 15050 14450 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR062
+L GND #PWR060
 U 1 1 5B15A8E5
 P 15850 15450
-F 0 "#PWR062" H 15850 15200 50  0001 C CNN
+F 0 "#PWR060" H 15850 15200 50  0001 C CNN
 F 1 "GND" H 15850 15300 50  0000 C CNN
 F 2 "" H 15850 15450 50  0001 C CNN
@@
 Touch Detection
 $Comp
-L +5V #PWR063
+L +5V #PWR061
 U 1 1 5B1416A6
 P 9150 950
-F 0 "#PWR063" H 9150 800 50  0001 C CNN
+F 0 "#PWR061" H 9150 800 50  0001 C CNN
 F 1 "+5V" H 9150 1090 50  0000 C CNN
 F 2 "" H 9150 950 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR064
+L GND #PWR062
 U 1 1 5B1416AC
 P 9150 1450
-F 0 "#PWR064" H 9150 1200 50  0001 C CNN
+F 0 "#PWR062" H 9150 1200 50  0001 C CNN
 F 1 "GND" H 9150 1300 50  0000 C CNN
 F 2 "" H 9150 1450 50  0001 C CNN
@@
 $EndComp
 $Comp
-L +3V3 #PWR065
+L +3V3 #PWR063
 U 1 1 5B14C8D4
 P 18550 8950
-F 0 "#PWR065" H 18550 8800 50  0001 C CNN
+F 0 "#PWR063" H 18550 8800 50  0001 C CNN
 F 1 "+3V3" H 18550 9090 50  0000 C CNN
 F 2 "" H 18550 8950 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR066
+L GND #PWR064
 U 1 1 5B14DF07
 P 18550 10300
-F 0 "#PWR066" H 18550 10050 50  0001 C CNN
+F 0 "#PWR064" H 18550 10050 50  0001 C CNN
 F 1 "GND" H 18550 10150 50  0000 C CNN
 F 2 "" H 18550 10300 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR067
+L GND #PWR065
 U 1 1 5B162B78
 P 12550 9100
-F 0 "#PWR067" H 12550 8850 50  0001 C CNN
+F 0 "#PWR065" H 12550 8850 50  0001 C CNN
 F 1 "GND" H 12550 8950 50  0000 C CNN
 F 2 "" H 12550 9100 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR068
+L GND #PWR066
 U 1 1 5B14D7E1
 P 3550 9050
-F 0 "#PWR068" H 3550 8800 50  0001 C CNN
+F 0 "#PWR066" H 3550 8800 50  0001 C CNN
 F 1 "GND" H 3550 8900 50  0000 C CNN
 F 2 "" H 3550 9050 50  0001 C CNN
@@
 SDA2
 $Comp
-L GND #PWR069
+L GND #PWR067
 U 1 1 5B15B9DB
 P 9400 9000
-F 0 "#PWR069" H 9400 8750 50  0001 C CNN
+F 0 "#PWR067" H 9400 8750 50  0001 C CNN
 F 1 "GND" H 9400 8850 50  0000 C CNN
 F 2 "" H 9400 9000 50  0001 C CNN
@@
 $EndComp
 $Comp
-L +3V3 #PWR070
+L +3V3 #PWR068
 U 1 1 5B15BED8
 P 9400 8500
-F 0 "#PWR070" H 9400 8350 50  0001 C CNN
+F 0 "#PWR068" H 9400 8350 50  0001 C CNN
 F 1 "+3V3" H 9400 8640 50  0000 C CNN
 F 2 "" H 9400 8500 50  0001 C CNN
@@
 Wire Wire Line
 	20350 13900 20450 13900
-Wire Wire Line
-	3150 1400 8050 1400
 Connection ~ 3800 1400
 Wire Wire Line
-	4050 1350 4050 1400
+	4050 1400 4050 1350
 Connection ~ 4050 1400
 Wire Wire Line
-	4300 1350 4300 1400
+	4300 1400 4300 1350
 Connection ~ 4300 1400
 Wire Wire Line
-	4550 1350 4550 1400
+	4550 1400 4550 1350
 Connection ~ 4550 1400
 Wire Wire Line
-	4800 1350 4800 1400
+	4800 1400 4800 1350
 Connection ~ 4800 1400
 Wire Wire Line
-	5050 1350 5050 1400
+	5050 1400 5050 1350
 Connection ~ 5050 1400
 Wire Wire Line
-	5300 1350 5300 1400
+	5300 1400 5300 1350
 Connection ~ 5300 1400
 Wire Wire Line
-	5550 1350 5550 1400
+	5550 1400 5550 1350
 Connection ~ 5550 1400
 Wire Wire Line
-	5800 1350 5800 1400
+	5800 1400 5800 1350
 Connection ~ 5800 1400
 Wire Wire Line
-	6050 1350 6050 1400
+	6050 1400 6050 1350
 Connection ~ 6050 1400
 Wire Wire Line
-	6300 1350 6300 1400
+	6300 1400 6300 1350
 Connection ~ 6300 1400
 Wire Wire Line
-	6550 1350 6550 1400
+	6550 1400 6550 1350
 Connection ~ 6550 1400
 Wire Wire Line
-	6800 1350 6800 1400
+	6800 1400 6800 1350
 Connection ~ 6800 1400
 Wire Wire Line
-	7050 1350 7050 1400
+	7050 1400 7050 1350
 Connection ~ 7050 1400
 Wire Wire Line
-	7300 1350 7300 1400
+	7300 1400 7300 1350
 Connection ~ 7300 1400
 Wire Wire Line
-	7550 1350 7550 1400
+	7550 1400 7550 1350
 Connection ~ 7550 1400
 Wire Wire Line
-	7800 1350 7800 1400
+	7800 1400 7800 1350
 Connection ~ 7800 1400
 Wire Wire Line
-	3150 1000 8050 1000
+	3500 1000 8050 1000
 Connection ~ 3800 1000
 Wire Wire Line
@@
 	17200 10000 17200 8950
 Wire Wire Line
-	14750 8950 15450 8950
+	14750 8950 15950 8950
 Wire Wire Line
 	14750 9250 14900 9250
@@
 	17000 9600 16900 9600
 Wire Wire Line
-	14750 8850 15150 8850
+	14750 8850 15600 8850
 Wire Wire Line
-	15450 8850 17100 8850
+	15900 8850 17100 8850
 Wire Wire Line
-	17200 8950 15750 8950
+	17200 8950 16250 8950
 Wire Wire Line
 	14750 9350 17000 9350
@@
 Connection ~ 7200 9700
 Wire Wire Line
-	3500 950  3500 1000
-Wire Wire Line
-	3150 950  3150 1000
-Connection ~ 3500 1000
-Wire Wire Line
-	3150 1350 3150 1400
-Wire Wire Line
 	15200 14600 15400 14600
 Wire Wire Line
@@
 	10750 8850 11250 8850
 $Comp
-L +5V #PWR071
+L +5V #PWR069
 U 1 1 5B168232
 P 14700 12750
-F 0 "#PWR071" H 14700 12600 50  0001 C CNN
+F 0 "#PWR069" H 14700 12600 50  0001 C CNN
 F 1 "+5V" H 14700 12890 50  0000 C CNN
 F 2 "" H 14700 12750 50  0001 C CNN
@@
 	1    0    0    -1
 $EndComp
+NoConn ~ 12000 10900
+NoConn ~ 12000 11100
+NoConn ~ 12000 11400
+NoConn ~ 12000 11500
+NoConn ~ 12000 11800
+NoConn ~ 12000 12000
+NoConn ~ 12000 12100
+NoConn ~ 12000 12400
+NoConn ~ 12000 12500
+NoConn ~ 12700 12800
+NoConn ~ 12700 12900
+NoConn ~ 12700 13200
+NoConn ~ 12700 13300
+NoConn ~ 13000 13400
+NoConn ~ 13000 13500
+NoConn ~ 12700 13700
+NoConn ~ 12700 13800
+NoConn ~ 13000 13900
+NoConn ~ 13000 14000
+NoConn ~ 12700 14100
+NoConn ~ 12700 14200
+NoConn ~ 13000 14300
+NoConn ~ 13000 14400
+NoConn ~ 12700 14500
+NoConn ~ 12700 14600
+NoConn ~ 13000 14700
+NoConn ~ 13000 14800
+NoConn ~ 12700 14900
+NoConn ~ 12700 15000
+NoConn ~ 12000 15200
+NoConn ~ 2300 15200
+NoConn ~ 2300 15100
+NoConn ~ 2600 15000
+NoConn ~ 2600 14900
+NoConn ~ 2300 14800
+NoConn ~ 2300 14700
+NoConn ~ 2600 14600
+NoConn ~ 2600 14500
+NoConn ~ 2300 14400
+NoConn ~ 2300 14300
+NoConn ~ 2600 14200
+NoConn ~ 2300 13500
+NoConn ~ 2300 13400
+NoConn ~ 2600 13300
+NoConn ~ 2600 13200
+NoConn ~ 2300 13100
+NoConn ~ 2300 13000
+NoConn ~ 2600 12900
+NoConn ~ 2600 12800
+NoConn ~ 2300 12700
+NoConn ~ 2300 12600
+NoConn ~ 2600 12500
+NoConn ~ 2600 12400
+NoConn ~ 2300 12300
+NoConn ~ 2300 12200
+NoConn ~ 2600 12100
+NoConn ~ 2600 12000
+$Comp
+L R R105
+U 1 1 5B182269
+P 13300 10150
+F 0 "R105" V 13380 10150 50  0000 C CNN
+F 1 "R" V 13300 10150 50  0000 C CNN
+F 2 "" V 13230 10150 50  0001 C CNN
+F 3 "" H 13300 10150 50  0001 C CNN
+	1    13300 10150
+	0    1    1    0
+$EndComp
+Wire Wire Line
+	13450 10150 13550 10150
+Wire Wire Line
+	12850 10150 13150 10150
+Text Label 13550 10150 0    60   ~ 0
+SERIAL_PWR
+$Comp
+L +3V3 #PWR070
+U 1 1 5B1856B6
+P 12850 10150
+F 0 "#PWR070" H 12850 10000 50  0001 C CNN
+F 1 "+3V3" H 12850 10290 50  0000 C CNN
+F 2 "" H 12850 10150 50  0001 C CNN
+F 3 "" H 12850 10150 50  0001 C CNN
+	1    12850 10150
+	1    0    0    -1
+$EndComp
+NoConn ~ 12900 9000
+NoConn ~ 12900 9400
+NoConn ~ 12400 10300
+NoConn ~ 12400 10400
+NoConn ~ 12700 10500
+NoConn ~ 12700 10600
+Wire Wire Line
+	3800 1400 8050 1400
+Wire Wire Line
+	3500 950  3500 1000
+NoConn ~ 3950 8550
+NoConn ~ 3950 8650
 $EndSCHEMATC

Commit message: Started linking parts to footprints
Parts:
- removed J22: USB_B, symbol USB_B
- removed J26, J27: TEST_1P, symbol TEST_1P
- removed Q1, Q2: Q_NMOS_DGS, symbol Q_NMOS_DGS
- added J22: USB_OTG, Connectors_USB:USB_Micro-B_Molex-105017-0001, symbol USB_OTG
- added Q? (x2): Q_NMOS_GDS, symbol Q_NMOS_GDS
- added R106, R107: R, symbol R
- C1, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C2, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C3, C30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: footprint (none) -> Capacitors_SMD:C_0805
- C58, C61: footprint (none) -> Capacitors_Tantalum_SMD:CP_Tantalum_Case-E_EIA-7260-38_Reflow
- C64, C67: footprint (none) -> Capacitors_Tantalum_SMD:CP_Tantalum_Case-B_EIA-3528-21_Reflow
- D1, D10, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D11, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D12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: footprint (none) -> gsg-modules:APA102-2020
- J1, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J2, J20, J3, J4, J5, J6, J7, J8, J9: footprint (none) -> gsg-modules:TESTPOINT-50MIL
- J21: footprint (none) -> Pin_Headers:Pin_Header_Angled_1x06_Pitch1.27mm
- J23, J25: footprint (none) -> Connectors_JST:JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled
- J24: footprint (none) -> Pin_Headers:Pin_Header_Angled_1x06_Pitch1.00mm
- J29, J30, J31, J32, J33: footprint (none) -> Measurement_Points:Measurement_Point_Round-SMD-Pad_Big
- L1: footprint (none) -> Inductors_SMD:L_0805
- U7: footprint LQFP100 -> (none)
Connections:
- net GND: now also J22.5 (GND), J22.6 (Shield), Q?.3 (S)
- net USB_VBUS: now also J22.1 (VBUS)
- net at U4.6 (AUX_SDA): now also R106.2
- net at U4.7 (AUX_SCL): now also R107.2
- net at U3.1 (DO): now also Q?.1 (G)
- net at U3.2 (CO): now also Q?.1 (G)
- net at C43.2, C44.2, J25.2 (Pin_2)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: now also Q?.3 (S)
- new net: Q?.2 (D), Q?.2 (D)
- no-connect marks 65 -> 68
Other:
- moved on the sheet: C43, C44, J23, J25

Commit message: Paired up all footprints
Parts:
- Q1, Q2: renamed from Q?; footprint (none) -> TO_SOT_Packages_SMD:SOT-89-3
- R1, R10, R100, R101, R102, R103, R104, R105, R106, R107, R11, R12, R13, R14, R15, R16, R17, R18, R19, R2, R20, R21, R22, R23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: footprint (none) -> Resistors_SMD:R_0805
- RV1: footprint (none) -> Potentiometers:Potentiometer_Trimmer-EVM3S_R
- SW1: footprint (none) -> Buttons_Switches_SMD:SW_SPST_B3SL-1002P
- U1, U2: footprint (none) -> TO_SOT_Packages_SMD:SOT-553
- U3: footprint (none) -> TO_SOT_Packages_SMD:SOT-23-6
- U4: footprint (none) -> Housings_DFN_QFN:QFN-24_4x4mm_Pitch0.5mm_NoMask
- U5: footprint (none) -> TO_SOT_Packages_THT:TO-220-3_Horizontal
- U6: footprint (none) -> Housings_SSOP:TSSOP-14_4.4x5mm_Pitch0.65mm
- U7: footprint (none) -> Housings_QFP:LQFP-100_14x14mm_Pitch0.5mm
- U8: footprint (none) -> TO_SOT_Packages_SMD:SOT-223-3_TabPin2
- X1: footprint (none) -> badgelife:Badgelife-Shitty-2x2
- Y1: footprint (none) -> Crystals:Crystal_SMD_FOX_FE-2pin_7.5x5.0mm

Commit message: Fixed one 6pin header footprint
Parts:
- J24: footprint Pin_Headers:Pin_Header_Angled_1x06_Pitch1.00mm -> Pin_Headers:Pin_Header_Angled_1x06_Pitch1.27mm
Changed lines of the file:
@@
 F 0 "J24" H 13650 9400 50  0000 C CNN
 F 1 "Conn_01x06" H 13650 8700 50  0000 C CNN
-F 2 "Pin_Headers:Pin_Header_Angled_1x06_Pitch1.00mm" H 13650 9100 50  0001 C CNN
+F 2 "Pin_Headers:Pin_Header_Angled_1x06_Pitch1.27mm" H 13650 9100 50  0001 C CNN
 F 3 "" H 13650 9100 50  0001 C CNN
 	1    13650 9100

Commit message: Placing components wip, and fixing minor sch issues found along the way
Parts:
- added C71: C, Capacitors_SMD:C_0805, symbol C
- added R108, R109: R, Resistors_SMD:R_0805, symbol R
Connections:
- net +3V3: now also C71.1, R108.1, R109.1
- net GND: now also C71.2
- net SCL2: now also R108.2
- net SDA2: now also R109.2
