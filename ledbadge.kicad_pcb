# Repository mjbella/LED_Badge

File README:

#LED Badge KiCAD Project

This is a pcb badge with an MCU and tightly packed RGB LEDs (APA102).

## KiCad design ledbadge.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34: C; C_0603
C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C56, C59, C60, C62, C63, C65, C66, C68, C69, C70, C71: C; C_0805
C55, C57: 6.8p; C_0805
C58, C61: CP; CP_Tantalum_Case-E_EIA-7260-38_Reflow
C64, C67: CP; CP_Tantalum_Case-B_EIA-3528-21_Reflow
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128, D129, D130, D131, D132, D133, D134, D135, D136, D137, D138, D139, D140, D141, D142, D143, D144, D145, D146, D147, D148, D149, D150, D151, D152, D153, D154, D155, D156, D157, D158, D159, D160, D161, D162, D163, D164, D165, D166, D167, D168, D169, D170, D171, D172, D173, D174, D175, D176, D177, D178, D179, D180, D181, D182, D183, D184, D185, D186, D187, D188, D189, D190, D191, D192, D193, D194, D195, D196, D197, D198, D199, D200: APA102; APA102-2020
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J29, J30, J31, J32, J33: TEST_1P; TESTPOINT-50MIL
J21, J24: Conn_01x06; Pin_Header_Straight_1x06_Pitch2.54mm_SMD_Pin1Left
J22: USB_OTG; USB_Micro-B_Molex-105017-0001
J23, J25: Conn_01x02; JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled
J28: GS3
L1: Ferrite_Bead; L_0805
Q1, Q2: Q_NMOS_GDS; SOT-89-3
R1, R2, R6, R7, R8, R9, R15: R_Small; R_0805
R3: 10k; R_0805
R4, R5, R10, R11, R12, R13, R14, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R29, R30, R31, R32, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94, R95, R96, R97, R98, R99, R100, R101, R102, R103, R104, R105, R106, R107, R108, R109: R; R_0805
R28, R33, R59: 0; R_0805
RV1: POT; Potentiometer_Trimmer-EVM3S_R
SW1: SW_Push; SW_SPST_B3SL-1002P
U1, U2: 74AHCT1G125; SOT-553
U3: S-8252_(SOT23); SOT-23-6
U4: MPU-6000; QFN-24_4x4mm_Pitch0.5mm_NoMask
U5: L7805; TO-220-3_Horizontal
U6: MTCH105; TSSOP-14_4.4x5mm_Pitch0.65mm
U7: STM32F407VGTx; LQFP-100_14x14mm_Pitch0.5mm
U8: AZ1117-3.3; SOT-223-3_TabPin2
X1: Badgelife_shitty_connector; Badgelife-Shitty-2x2
Y1: Crystal; Crystal_SMD_FOX_FE-2pin_7.5x5.0mm

Connections (part):
+3V3: C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.2, C42.1, C45.1, C46.1, C56.2, C67.1, C68.1, C69.1, C71.1, L1.2, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R14.1, R31.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R105.2, R108.1, R109.1, RV1.1, U4.13 (VDD), U6.1 (VDD), U7.6 (VBAT), U7.11 (VDD), U7.19 (VDD), U7.28 (VDD), U7.50 (VDD), U7.75 (VDD), U7.100 (VDD), U8.2 (VO), X1.1 (VDD)
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C64.1, C65.1, C66.1, D1.5 (VCC), D2.5 (VCC), D3.5 (VCC), D4.5 (VCC), D5.5 (VCC), D6.5 (VCC), D7.5 (VCC), D8.5 (VCC), D9.5 (VCC), D10.5 (VCC), D11.5 (VCC), D12.5 (VCC), D13.5 (VCC), D14.5 (VCC), D15.5 (VCC), D16.5 (VCC), D17.5 (VCC), D18.5 (VCC), D19.5 (VCC), D20.5 (VCC), D21.5 (VCC), D22.5 (VCC), D23.5 (VCC), D24.5 (VCC), D25.5 (VCC), D26.5 (VCC), D27.5 (VCC), D28.5 (VCC), D29.5 (VCC), D30.5 (VCC), D31.5 (VCC), D32.5 (VCC), D33.5 (VCC), D34.5 (VCC), D35.5 (VCC), D36.5 (VCC), D37.5 (VCC), D38.5 (VCC), D39.5 (VCC), D40.5 (VCC), D41.5 (VCC), D42.5 (VCC), D43.5 (VCC)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
+BATT: C58.1, C59.1, C60.1, J23.1, R4.2, U5.1 (IN)
/ACCEL_INT: R10.2, R103.1, U4.12 (INT)
/DAC_OUT1: R22.1, R101.1
/LP_MODE_SEL: R41.2, U6.4 (MTPM)
/MOSI_3v3: R25.1, U1.2
/MOSI_5v_R: D1.2 (SDI), R1.1
/NRST: J21.5, R11.2, SW1.1, U7.14 (NRST)
/SCK20: D20.6 (CKO), D21.3 (CKI), J6.1
/SCK40: D40.6 (CKO), D41.3 (CKI), J16.1
/SCK60: D60.6 (CKO), D61.3 (CKI), J7.1
/SCK80: D80.6 (CKO), D81.3 (CKI), J17.1
/SCK100: D100.6 (CKO), D101.3 (CKI), J8.1
/SCK120: D120.6 (CKO), D121.3 (CKI), J18.1
/SCK140: D140.6 (CKO), D141.3 (CKI), J9.1
/SCK160: D160.6 (CKO), D161.3 (CKI), J19.1
/SCK180: D180.6 (CKO), D181.3 (CKI), J10.1
/SCK200: D200.6 (CKO), J20.1
/SCL: R9.2, R48.1, U4.23 (SCL/SCLK)
/SCL2: R56.1, R108.2, X1.4 (SDA)
/SCLK_3v3: R24.2, U2.2
/SCLK_5V_R: D1.3 (CKI), R2.1
/SDA: R8.2, R50.2, U4.24 (SDA/MOSI)
/SDA2: R58.2, R109.2, X1.3 (SCL)
/SDO20: D20.1 (SDO), D21.2 (SDI), J1.1
/SDO40: D40.1 (SDO), D41.2 (SDI), J11.1
/SDO60: D60.1 (SDO), D61.2 (SDI), J2.1
/SDO80: D80.1 (SDO), D81.2 (SDI), J12.1
/SDO100: D100.1 (SDO), D101.2 (SDI), J3.1
/SDO120: D120.1 (SDO), D121.2 (SDI), J13.1
/SDO140: D140.1 (SDO), D141.2 (SDI), J4.1
/SDO160: D160.1 (SDO), D161.2 (SDI), J14.1
/SDO180: D180.1 (SDO), D181.2 (SDI), J5.1
/SDO200: D200.1 (SDO), J15.1
/SENSITIVITY_ADJ: C70.1, R92.2, R101.2, U6.11 (MTSA)
/SERIAL_CTR: J24.2
/SERIAL_DTR: J24.6
/SERIAL_PWR: J24.3, R105.1
/SERIAL_RXI: J24.5, R12.1
/SERIAL_TXO: J24.4, R13.1
/SWCLK: J21.2, R30.2
/SWDIO: J21.4, R29.1
/SWO: J21.6, R44.2
/TOUCH0: R64.2, U6.2 (MTI0)
/TOUCH1: R65.2, U6.3 (MTI1)
/TOUCH2/GUARD: J33.1, U6.5 (MTI2/GUARD)
/TOUCH3: R76.2, U6.6 (MTI3)
/TOUCH4: R77.2, U6.7 (MTI4)
/USART1_RX: R13.2, R27.2
/USART1_TX: R12.2, R26.1
/USB_VBUS: J22.1 (VBUS), J28.3 (G3)
/VDDA: C47.1, C48.1, L1.1, R23.2, U7.22 (VDDA)
/~TOUCH0_DET: R36.2, R70.2, U6.13 (MTO0)
/~TOUCH1_DET: R37.2, R72.1, U6.12 (MTO1)
/~TOUCH2/GC: R38.2, R59.1, R74.2, U6.10 (MTO2/GC)
/~TOUCH3_DET: R39.2, R78.1, U6.9 (MTO3)
/~TOUCH4_DET: R40.2, R80.1, U6.8 (MTO4)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.1, C42.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.1, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, D1.4 (GND), D2.4 (GND), D3.4 (GND), D4.4 (GND), D5.4 (GND), D6.4 (GND), D7.4 (GND), D8.4 (GND), D9.4 (GND), D10.4 (GND), D11.4 (GND)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
unnamed: C43.1, R5.1, U3.4 (VC)
unnamed: C43.2, C44.2, J25.2, Q1.3 (S), U3.6 (VSS)
unnamed: C44.1, R4.1, U3.5 (VDD)
unnamed: C49.1, U4.10 (REGOUT)
unnamed: C50.1, U4.20 (CPOUT)
unnamed: C51.1, C52.1, R23.1, U7.21 (VREF+)
unnamed: C53.1, U7.49 (VCAP_1)
unnamed: C54.1, U7.73 (VCAP_2)
unnamed: C55.1, R28.2, Y1.1
unnamed: C57.1, R33.2, Y1.2
unnamed: C61.1, C62.1, C63.1, J28.1 (G1), U5.3 (OUT)
unnamed: D1.1 (SDO), D2.2 (SDI)
unnamed: D1.6 (CKO), D2.3 (CKI)
unnamed: D2.1 (SDO), D3.2 (SDI)
unnamed: D2.6 (CKO), D3.3 (CKI)
unnamed: D3.1 (SDO), D4.2 (SDI)
unnamed: D3.6 (CKO), D4.3 (CKI)
unnamed: D4.1 (SDO), D5.2 (SDI)
unnamed: D4.6 (CKO), D5.3 (CKI)
unnamed: D5.1 (SDO), D6.2 (SDI)
unnamed: D5.6 (CKO), D6.3 (CKI)
unnamed: D6.1 (SDO), D7.2 (SDI)
unnamed: D6.6 (CKO), D7.3 (CKI)
unnamed: D7.1 (SDO), D8.2 (SDI)
unnamed: D7.6 (CKO), D8.3 (CKI)
unnamed: D8.1 (SDO), D9.2 (SDI)
unnamed: D8.6 (CKO), D9.3 (CKI)
unnamed: D10.1 (SDO), D11.2 (SDI)
unnamed: D9.1 (SDO), D10.2 (SDI)
unnamed: D9.6 (CKO), D10.3 (CKI)
unnamed: D10.6 (CKO), D11.3 (CKI)
unnamed: D11.1 (SDO), D12.2 (SDI)
unnamed: D11.6 (CKO), D12.3 (CKI)
unnamed: D12.1 (SDO), D13.2 (SDI)
unnamed: D12.6 (CKO), D13.3 (CKI)
unnamed: D13.1 (SDO), D14.2 (SDI)
unnamed: D13.6 (CKO), D14.3 (CKI)
unnamed: D14.1 (SDO), D15.2 (SDI)
unnamed: D14.6 (CKO), D15.3 (CKI)
unnamed: D15.1 (SDO), D16.2 (SDI)
unnamed: D15.6 (CKO), D16.3 (CKI)
unnamed: D16.1 (SDO), D17.2 (SDI)
unnamed: D16.6 (CKO), D17.3 (CKI)
unnamed: D17.1 (SDO), D18.2 (SDI)
unnamed: D17.6 (CKO), D18.3 (CKI)
unnamed: D18.1 (SDO), D19.2 (SDI)
unnamed: D18.6 (CKO), D19.3 (CKI)
unnamed: D19.1 (SDO), D20.2 (SDI)
unnamed: D19.6 (CKO), D20.3 (CKI)
unnamed: D21.1 (SDO), D22.2 (SDI)
unnamed: D21.6 (CKO), D22.3 (CKI)
unnamed: D22.1 (SDO), D23.2 (SDI)
unnamed: D22.6 (CKO), D23.3 (CKI)
unnamed: D23.1 (SDO), D24.2 (SDI)
unnamed: D23.6 (CKO), D24.3 (CKI)
unnamed: D24.1 (SDO), D25.2 (SDI)
unnamed: D24.6 (CKO), D25.3 (CKI)
unnamed: D25.1 (SDO), D26.2 (SDI)
unnamed: D25.6 (CKO), D26.3 (CKI)
unnamed: D26.1 (SDO), D27.2 (SDI)
unnamed: D26.6 (CKO), D27.3 (CKI)
unnamed: D27.1 (SDO), D28.2 (SDI)
unnamed: D27.6 (CKO), D28.3 (CKI)
unnamed: D28.1 (SDO), D29.2 (SDI)
unnamed: D28.6 (CKO), D29.3 (CKI)
unnamed: D29.1 (SDO), D30.2 (SDI)
unnamed: D29.6 (CKO), D30.3 (CKI)
unnamed: D30.1 (SDO), D31.2 (SDI)
unnamed: D30.6 (CKO), D31.3 (CKI)
unnamed: D31.1 (SDO), D32.2 (SDI)
unnamed: D31.6 (CKO), D32.3 (CKI)
unnamed: D32.1 (SDO), D33.2 (SDI)
unnamed: D32.6 (CKO), D33.3 (CKI)
unnamed: D33.1 (SDO), D34.2 (SDI)
unnamed: D33.6 (CKO), D34.3 (CKI)
unnamed: D34.1 (SDO), D35.2 (SDI)
unnamed: D34.6 (CKO), D35.3 (CKI)
unnamed: D35.1 (SDO), D36.2 (SDI)
unnamed: D35.6 (CKO), D36.3 (CKI)
unnamed: D36.1 (SDO), D37.2 (SDI)
unnamed: D36.6 (CKO), D37.3 (CKI)
unnamed: D37.1 (SDO), D38.2 (SDI)
unnamed: D37.6 (CKO), D38.3 (CKI)
unnamed: D38.1 (SDO), D39.2 (SDI)
unnamed: D38.6 (CKO), D39.3 (CKI)
unnamed: D39.1 (SDO), D40.2 (SDI)
unnamed: D39.6 (CKO), D40.3 (CKI)
unnamed: D41.1 (SDO), D42.2 (SDI)
unnamed: D41.6 (CKO), D42.3 (CKI)
unnamed: D42.1 (SDO), D43.2 (SDI)
unnamed: D42.6 (CKO), D43.3 (CKI)
unnamed: D43.1 (SDO), D44.2 (SDI)
unnamed: D43.6 (CKO), D44.3 (CKI)
unnamed: D44.1 (SDO), D45.2 (SDI)
unnamed: D44.6 (CKO), D45.3 (CKI)
unnamed: D45.1 (SDO), D46.2 (SDI)
unnamed: D45.6 (CKO), D46.3 (CKI)
unnamed: D46.1 (SDO), D47.2 (SDI)
unnamed: D46.6 (CKO), D47.3 (CKI)
unnamed: D47.1 (SDO), D48.2 (SDI)
unnamed: D47.6 (CKO), D48.3 (CKI)
unnamed: D48.1 (SDO), D49.2 (SDI)
unnamed: D48.6 (CKO), D49.3 (CKI)
unnamed: D49.1 (SDO), D50.2 (SDI)
unnamed: D49.6 (CKO), D50.3 (CKI)
unnamed: D50.1 (SDO), D51.2 (SDI)
unnamed: D50.6 (CKO), D51.3 (CKI)
unnamed: D51.1 (SDO), D52.2 (SDI)
unnamed: D51.6 (CKO), D52.3 (CKI)
unnamed: D52.1 (SDO), D53.2 (SDI)
unnamed: D52.6 (CKO), D53.3 (CKI)
unnamed: D53.1 (SDO), D54.2 (SDI)
unnamed: D53.6 (CKO), D54.3 (CKI)
unnamed: D54.1 (SDO), D55.2 (SDI)
unnamed: D54.6 (CKO), D55.3 (CKI)
unnamed: D55.1 (SDO), D56.2 (SDI)
unnamed: D55.6 (CKO), D56.3 (CKI)
unnamed: D56.1 (SDO), D57.2 (SDI)
unnamed: D56.6 (CKO), D57.3 (CKI)
unnamed: D57.1 (SDO), D58.2 (SDI)
unnamed: D57.6 (CKO), D58.3 (CKI)
unnamed: D58.1 (SDO), D59.2 (SDI)
unnamed: D58.6 (CKO), D59.3 (CKI)
unnamed: D59.1 (SDO), D60.2 (SDI)
unnamed: D59.6 (CKO), D60.3 (CKI)
unnamed: D61.1 (SDO), D62.2 (SDI)
unnamed: D61.6 (CKO), D62.3 (CKI)
unnamed: D62.1 (SDO), D63.2 (SDI)
unnamed: D62.6 (CKO), D63.3 (CKI)
unnamed: D63.1 (SDO), D64.2 (SDI)
unnamed: D63.6 (CKO), D64.3 (CKI)
unnamed: D64.1 (SDO), D65.2 (SDI)
unnamed: D64.6 (CKO), D65.3 (CKI)
unnamed: D65.1 (SDO), D66.2 (SDI)
unnamed: D65.6 (CKO), D66.3 (CKI)
unnamed: D66.1 (SDO), D67.2 (SDI)
unnamed: D66.6 (CKO), D67.3 (CKI)
unnamed: D67.1 (SDO), D68.2 (SDI)
unnamed: D67.6 (CKO), D68.3 (CKI)
unnamed: D68.1 (SDO), D69.2 (SDI)
unnamed: D68.6 (CKO), D69.3 (CKI)
unnamed: D69.1 (SDO), D70.2 (SDI)
unnamed: D69.6 (CKO), D70.3 (CKI)
unnamed: D70.1 (SDO), D71.2 (SDI)
unnamed: D70.6 (CKO), D71.3 (CKI)
unnamed: D71.1 (SDO), D72.2 (SDI)
unnamed: D71.6 (CKO), D72.3 (CKI)
unnamed: D72.1 (SDO), D73.2 (SDI)
unnamed: D72.6 (CKO), D73.3 (CKI)
unnamed: D73.1 (SDO), D74.2 (SDI)
unnamed: D73.6 (CKO), D74.3 (CKI)
unnamed: D74.1 (SDO), D75.2 (SDI)
unnamed: D74.6 (CKO), D75.3 (CKI)
unnamed: D75.1 (SDO), D76.2 (SDI)
unnamed: D75.6 (CKO), D76.3 (CKI)
unnamed: D76.1 (SDO), D77.2 (SDI)
unnamed: D76.6 (CKO), D77.3 (CKI)
unnamed: D77.1 (SDO), D78.2 (SDI)
unnamed: D77.6 (CKO), D78.3 (CKI)
unnamed: D78.1 (SDO), D79.2 (SDI)
unnamed: D78.6 (CKO), D79.3 (CKI)
unnamed: D79.1 (SDO), D80.2 (SDI)
unnamed: D79.6 (CKO), D80.3 (CKI)
unnamed: D81.1 (SDO), D82.2 (SDI)
unnamed: D81.6 (CKO), D82.3 (CKI)
unnamed: D82.1 (SDO), D83.2 (SDI)
unnamed: D82.6 (CKO), D83.3 (CKI)
unnamed: D83.1 (SDO), D84.2 (SDI)
unnamed: D83.6 (CKO), D84.3 (CKI)
unnamed: D84.1 (SDO), D85.2 (SDI)
unnamed: D84.6 (CKO), D85.3 (CKI)
unnamed: D85.1 (SDO), D86.2 (SDI)
unnamed: D85.6 (CKO), D86.3 (CKI)
unnamed: D86.1 (SDO), D87.2 (SDI)
unnamed: D86.6 (CKO), D87.3 (CKI)
unnamed: D87.1 (SDO), D88.2 (SDI)
unnamed: D87.6 (CKO), D88.3 (CKI)
unnamed: D88.1 (SDO), D89.2 (SDI)
unnamed: D88.6 (CKO), D89.3 (CKI)
unnamed: D89.1 (SDO), D90.2 (SDI)
unnamed: D89.6 (CKO), D90.3 (CKI)
unnamed: D90.1 (SDO), D91.2 (SDI)
unnamed: D90.6 (CKO), D91.3 (CKI)
unnamed: D91.1 (SDO), D92.2 (SDI)
unnamed: D91.6 (CKO), D92.3 (CKI)
unnamed: D92.1 (SDO), D93.2 (SDI)
unnamed: D92.6 (CKO), D93.3 (CKI)
unnamed: D93.1 (SDO), D94.2 (SDI)
unnamed: D93.6 (CKO), D94.3 (CKI)
unnamed: D94.1 (SDO), D95.2 (SDI)
unnamed: D94.6 (CKO), D95.3 (CKI)
unnamed: D95.1 (SDO), D96.2 (SDI)
unnamed: D95.6 (CKO), D96.3 (CKI)
unnamed: D96.1 (SDO), D97.2 (SDI)
unnamed: D96.6 (CKO), D97.3 (CKI)
unnamed: D97.1 (SDO), D98.2 (SDI)
unnamed: D97.6 (CKO), D98.3 (CKI)
unnamed: D98.1 (SDO), D99.2 (SDI)
unnamed: D98.6 (CKO), D99.3 (CKI)
unnamed: D99.1 (SDO), D100.2 (SDI)
unnamed: D99.6 (CKO), D100.3 (CKI)
unnamed: D101.1 (SDO), D102.2 (SDI)
unnamed: D101.6 (CKO), D102.3 (CKI)
unnamed: D102.1 (SDO), D103.2 (SDI)
unnamed: D102.6 (CKO), D103.3 (CKI)
unnamed: D103.1 (SDO), D104.2 (SDI)
unnamed: D103.6 (CKO), D104.3 (CKI)
unnamed: D104.1 (SDO), D105.2 (SDI)
unnamed: D104.6 (CKO), D105.3 (CKI)
unnamed: D105.1 (SDO), D106.2 (SDI)
unnamed: D105.6 (CKO), D106.3 (CKI)
unnamed: D106.1 (SDO), D107.2 (SDI)
unnamed: D106.6 (CKO), D107.3 (CKI)
unnamed: D107.1 (SDO), D108.2 (SDI)
unnamed: D107.6 (CKO), D108.3 (CKI)
unnamed: D108.1 (SDO), D109.2 (SDI)
unnamed: D108.6 (CKO), D109.3 (CKI)
unnamed: D109.1 (SDO), D110.2 (SDI)
unnamed: D109.6 (CKO), D110.3 (CKI)
unnamed: D110.1 (SDO), D111.2 (SDI)
unnamed: D110.6 (CKO), D111.3 (CKI)
unnamed: D111.1 (SDO), D112.2 (SDI)
unnamed: D111.6 (CKO), D112.3 (CKI)
unnamed: D112.1 (SDO), D113.2 (SDI)
unnamed: D112.6 (CKO), D113.3 (CKI)
unnamed: D113.1 (SDO), D114.2 (SDI)
unnamed: D113.6 (CKO), D114.3 (CKI)
unnamed: D114.1 (SDO), D115.2 (SDI)
unnamed: D114.6 (CKO), D115.3 (CKI)
unnamed: D115.1 (SDO), D116.2 (SDI)
unnamed: D115.6 (CKO), D116.3 (CKI)
unnamed: D116.1 (SDO), D117.2 (SDI)
unnamed: D116.6 (CKO), D117.3 (CKI)
unnamed: D117.1 (SDO), D118.2 (SDI)
unnamed: D117.6 (CKO), D118.3 (CKI)
unnamed: D118.1 (SDO), D119.2 (SDI)
unnamed: D118.6 (CKO), D119.3 (CKI)
unnamed: D119.1 (SDO), D120.2 (SDI)
unnamed: D119.6 (CKO), D120.3 (CKI)
unnamed: D121.1 (SDO), D122.2 (SDI)
unnamed: D121.6 (CKO), D122.3 (CKI)
unnamed: D122.1 (SDO), D123.2 (SDI)
unnamed: D122.6 (CKO), D123.3 (CKI)
unnamed: D123.1 (SDO), D124.2 (SDI)
unnamed: D123.6 (CKO), D124.3 (CKI)
unnamed: D124.1 (SDO), D125.2 (SDI)
unnamed: D124.6 (CKO), D125.3 (CKI)
unnamed: D125.1 (SDO), D126.2 (SDI)
unnamed: D125.6 (CKO), D126.3 (CKI)
unnamed: D126.1 (SDO), D127.2 (SDI)
unnamed: D126.6 (CKO), D127.3 (CKI)
unnamed: D127.1 (SDO), D128.2 (SDI)
unnamed: D127.6 (CKO), D128.3 (CKI)
unnamed: D128.1 (SDO), D129.2 (SDI)
unnamed: D128.6 (CKO), D129.3 (CKI)
unnamed: D129.1 (SDO), D130.2 (SDI)
unnamed: D129.6 (CKO), D130.3 (CKI)
unnamed: D130.1 (SDO), D131.2 (SDI)
unnamed: D130.6 (CKO), D131.3 (CKI)
unnamed: D131.1 (SDO), D132.2 (SDI)
unnamed: D131.6 (CKO), D132.3 (CKI)
unnamed: D132.1 (SDO), D133.2 (SDI)
unnamed: D132.6 (CKO), D133.3 (CKI)
unnamed: D133.1 (SDO), D134.2 (SDI)
unnamed: D133.6 (CKO), D134.3 (CKI)
unnamed: D134.1 (SDO), D135.2 (SDI)
unnamed: D134.6 (CKO), D135.3 (CKI)
unnamed: D135.1 (SDO), D136.2 (SDI)
unnamed: D135.6 (CKO), D136.3 (CKI)
unnamed: D136.1 (SDO), D137.2 (SDI)
unnamed: D136.6 (CKO), D137.3 (CKI)
unnamed: D137.1 (SDO), D138.2 (SDI)
unnamed: D137.6 (CKO), D138.3 (CKI)
unnamed: D138.1 (SDO), D139.2 (SDI)
unnamed: D138.6 (CKO), D139.3 (CKI)
unnamed: D139.1 (SDO), D140.2 (SDI)
unnamed: D139.6 (CKO), D140.3 (CKI)
unnamed: D141.1 (SDO), D142.2 (SDI)
unnamed: D141.6 (CKO), D142.3 (CKI)
unnamed: D142.1 (SDO), D143.2 (SDI)
unnamed: D142.6 (CKO), D143.3 (CKI)
unnamed: D143.1 (SDO), D144.2 (SDI)
unnamed: D143.6 (CKO), D144.3 (CKI)
unnamed: D144.1 (SDO), D145.2 (SDI)
unnamed: D144.6 (CKO), D145.3 (CKI)
unnamed: D145.1 (SDO), D146.2 (SDI)
unnamed: D145.6 (CKO), D146.3 (CKI)
unnamed: D146.1 (SDO), D147.2 (SDI)
unnamed: D146.6 (CKO), D147.3 (CKI)
unnamed: D147.1 (SDO), D148.2 (SDI)
unnamed: D147.6 (CKO), D148.3 (CKI)
unnamed: D148.1 (SDO), D149.2 (SDI)
unnamed: D148.6 (CKO), D149.3 (CKI)
unnamed: D149.1 (SDO), D150.2 (SDI)
unnamed: D149.6 (CKO), D150.3 (CKI)
unnamed: D150.1 (SDO), D151.2 (SDI)
unnamed: D150.6 (CKO), D151.3 (CKI)
unnamed: D151.1 (SDO), D152.2 (SDI)
unnamed: D151.6 (CKO), D152.3 (CKI)
unnamed: D152.1 (SDO), D153.2 (SDI)
unnamed: D152.6 (CKO), D153.3 (CKI)
unnamed: D153.1 (SDO), D154.2 (SDI)
unnamed: D153.6 (CKO), D154.3 (CKI)
unnamed: D154.1 (SDO), D155.2 (SDI)
unnamed: D154.6 (CKO), D155.3 (CKI)
unnamed: D155.1 (SDO), D156.2 (SDI)
unnamed: D155.6 (CKO), D156.3 (CKI)
unnamed: D156.1 (SDO), D157.2 (SDI)
unnamed: D156.6 (CKO), D157.3 (CKI)
unnamed: D157.1 (SDO), D158.2 (SDI)
unnamed: D157.6 (CKO), D158.3 (CKI)
unnamed: D158.1 (SDO), D159.2 (SDI)
unnamed: D158.6 (CKO), D159.3 (CKI)
unnamed: D159.1 (SDO), D160.2 (SDI)
unnamed: D159.6 (CKO), D160.3 (CKI)
unnamed: D161.1 (SDO), D162.2 (SDI)
unnamed: D161.6 (CKO), D162.3 (CKI)
unnamed: D162.1 (SDO), D163.2 (SDI)
unnamed: D162.6 (CKO), D163.3 (CKI)
unnamed: D163.1 (SDO), D164.2 (SDI)
unnamed: D163.6 (CKO), D164.3 (CKI)
unnamed: D164.1 (SDO), D165.2 (SDI)
unnamed: D164.6 (CKO), D165.3 (CKI)
unnamed: D165.1 (SDO), D166.2 (SDI)
unnamed: D165.6 (CKO), D166.3 (CKI)
unnamed: D166.1 (SDO), D167.2 (SDI)
unnamed: D166.6 (CKO), D167.3 (CKI)
unnamed: D167.1 (SDO), D168.2 (SDI)
unnamed: D167.6 (CKO), D168.3 (CKI)
unnamed: D168.1 (SDO), D169.2 (SDI)
unnamed: D168.6 (CKO), D169.3 (CKI)
unnamed: D169.1 (SDO), D170.2 (SDI)
unnamed: D169.6 (CKO), D170.3 (CKI)
unnamed: D170.1 (SDO), D171.2 (SDI)
unnamed: D170.6 (CKO), D171.3 (CKI)
unnamed: D171.1 (SDO), D172.2 (SDI)
unnamed: D171.6 (CKO), D172.3 (CKI)
unnamed: D172.1 (SDO), D173.2 (SDI)
unnamed: D172.6 (CKO), D173.3 (CKI)
unnamed: D173.1 (SDO), D174.2 (SDI)
unnamed: D173.6 (CKO), D174.3 (CKI)
unnamed: D174.1 (SDO), D175.2 (SDI)
unnamed: D174.6 (CKO), D175.3 (CKI)
unnamed: D175.1 (SDO), D176.2 (SDI)
unnamed: D175.6 (CKO), D176.3 (CKI)
unnamed: D176.1 (SDO), D177.2 (SDI)
unnamed: D176.6 (CKO), D177.3 (CKI)
unnamed: D177.1 (SDO), D178.2 (SDI)
unnamed: D177.6 (CKO), D178.3 (CKI)
unnamed: D178.1 (SDO), D179.2 (SDI)
unnamed: D178.6 (CKO), D179.3 (CKI)
unnamed: D179.1 (SDO), D180.2 (SDI)
unnamed: D179.6 (CKO), D180.3 (CKI)
unnamed: D181.1 (SDO), D182.2 (SDI)
unnamed: D181.6 (CKO), D182.3 (CKI)
unnamed: D182.1 (SDO), D183.2 (SDI)
unnamed: D182.6 (CKO), D183.3 (CKI)
unnamed: D183.1 (SDO), D184.2 (SDI)
unnamed: D183.6 (CKO), D184.3 (CKI)
unnamed: D184.1 (SDO), D185.2 (SDI)
unnamed: D184.6 (CKO), D185.3 (CKI)
unnamed: D185.1 (SDO), D186.2 (SDI)
unnamed: D185.6 (CKO), D186.3 (CKI)
unnamed: D186.1 (SDO), D187.2 (SDI)
unnamed: D186.6 (CKO), D187.3 (CKI)
unnamed: D187.1 (SDO), D188.2 (SDI)
unnamed: D187.6 (CKO), D188.3 (CKI)
unnamed: D188.1 (SDO), D189.2 (SDI)
unnamed: D188.6 (CKO), D189.3 (CKI)
unnamed: D189.1 (SDO), D190.2 (SDI)
unnamed: D189.6 (CKO), D190.3 (CKI)
unnamed: D190.1 (SDO), D191.2 (SDI)
unnamed: D190.6 (CKO), D191.3 (CKI)
unnamed: D191.1 (SDO), D192.2 (SDI)
unnamed: D191.6 (CKO), D192.3 (CKI)
unnamed: D192.1 (SDO), D193.2 (SDI)
unnamed: D192.6 (CKO), D193.3 (CKI)
unnamed: D193.1 (SDO), D194.2 (SDI)
unnamed: D193.6 (CKO), D194.3 (CKI)
unnamed: D194.1 (SDO), D195.2 (SDI)
unnamed: D194.6 (CKO), D195.3 (CKI)
unnamed: D195.1 (SDO), D196.2 (SDI)
unnamed: D195.6 (CKO), D196.3 (CKI)
unnamed: D196.1 (SDO), D197.2 (SDI)
unnamed: D196.6 (CKO), D197.3 (CKI)
unnamed: D197.1 (SDO), D198.2 (SDI)
unnamed: D197.6 (CKO), D198.3 (CKI)
unnamed: D198.1 (SDO), D199.2 (SDI)
unnamed: D198.6 (CKO), D199.3 (CKI)
unnamed: D199.1 (SDO), D200.2 (SDI)
unnamed: D199.6 (CKO), D200.3 (CKI)
unnamed: J21.1, R3.1
unnamed: J23.2, J25.1, R5.2
unnamed: J29.1, R64.1
unnamed: J30.1, R65.1
unnamed: J31.1, R76.1
unnamed: J32.1, R77.1
unnamed: Q1.1 (G), U3.1 (DO)
unnamed: Q1.2 (D), Q2.2 (D)
unnamed: Q2.1 (G), U3.2 (CO)
unnamed: R1.2, U1.4
unnamed: R2.2, U2.4
unnamed: R7.2, U4.8 (~CS)
unnamed: R14.2, R16.1, U7.94 (BOOT0)
unnamed: R6.2, R15.1, U4.9 (AD0/MISO)
unnamed: R17.1, U3.3 (VM)
unnamed: R18.2, U7.23 (ADC1_IN0/ADC2_IN0/ADC3_IN0/ETH_CRS/SYS_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)
unnamed: R19.1, U7.24 (ADC1_IN1/ADC2_IN1/ADC3_IN1/ETH_REF_CLK/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)
unnamed: R20.2, U7.25 (ADC1_IN2/ADC2_IN2/ADC3_IN2/ETH_MDIO/TIM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)
unnamed: R21.1, U7.26 (ADC1_IN3/ADC2_IN3/ADC3_IN3/ETH_COL/TIM2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)
unnamed: R22.2, U7.29 (ADC1_IN4/ADC2_IN4/DAC_OUT1/DCMI_HSYNC/I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)
unnamed: R24.1, U7.30 (ADC1_IN5/ADC2_IN5/DAC_OUT2/SPI1_SCK/TIM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)
unnamed: R25.2, U7.32 (ADC1_IN7/ADC2_IN7/ETH_CRS_DV/ETH_RX_DV/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)
unnamed: R26.2, U7.68 (DAC_EXTI9/DCMI_D0/I2C3_SMBA/TIM1_CH2/US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)
unnamed: R27.1, U7.69 (DCMI_D1/TIM1_CH3/USART1_RX/USB_OTG_FS_I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)
unnamed: R28.1, U7.12 (PH0/RCC_OSC_IN)
unnamed: R29.2, U7.72 (SYS_JTMS-SWDIO/PA13)
unnamed: R30.1, U7.76 (SYS_JTCK-SWCLK/PA14)
unnamed: R31.2, R35.1, U7.37 (BOOT1/PB2)
unnamed: R32.1, U7.97 (PE0/DCMI_D2/FSMC_NBL0/TIM4_ETR)
unnamed: R33.1, U7.13 (PH1/RCC_OSC_OUT)
unnamed: R34.2, U7.98 (PE1/DCMI_D3/FSMC_NBL1)
unnamed: R42.1, U7.1 (PE2/ETH_TXD3/FSMC_A23/SYS_TRACECLK)
unnamed: R43.2, U7.2 (PE3/FSMC_A19/SYS_TRACED0)
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
Notes on the sheet:
This is actually going to be a SMPS drop-in replacement for the 7805
Battery Protection
Regulators
Touch Sensitivity
Populating R23 with a 0ohm resistor will enable the guard funciton on the MTCH105.
6DOF IMU
Touch Detection

Board: 4 copper layers, 165.1 x 76.2 mm, 400 parts (238 on the bottom side), 534 nets.
